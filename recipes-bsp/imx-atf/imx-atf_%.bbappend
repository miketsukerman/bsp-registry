FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:rom5721-1g-db5901 = " file://0001-add-imx8mm-rom5721a1-1G-support.patch "
