IMX_M4_DEMOS:mx8ulp-nxp-bsp = "imx-m33-adv:do_deploy"
M4_DEFAULT_IMAGE:mx8ulp-nxp-bsp = "adv_imxcm33.bin"
